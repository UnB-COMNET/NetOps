options:
  parameters:
    author: jon
    generate_options: qt_gui
    id: metric_e2e_path_availability_pct_msg
    output_language: python
    title: Metric e2e_path_availability_pct (msg)
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_NIL
    period: '1000'
  states: {}
- name: netmon_metric_e2e_path_availability_pct_msg_0
  id: netmon_metric_e2e_path_availability_pct_msg
  parameters:
    node: h1
    value: '0.0'
    labels_json: '{}'
    details_json: '{}'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    color: '""'
    debug: 'True'
    show: 'True'
    stream: 'False'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_metric_e2e_path_availability_pct_msg_0, tick]
- [netmon_metric_e2e_path_availability_pct_msg_0, metrics, blocks_message_debug_0, print]

metadata:
  file_format: 1
