options:
  parameters:
    author: jon
    generate_options: qt_gui
    id: metric_microburst_queue_occupancy_pct_peak_auto
    output_language: python
    title: Metric microburst_queue_occupancy_pct_peak (auto)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_NIL
    period: '1000'
  states: {}
- name: netmon_metric_microburst_queue_occupancy_pct_peak_auto_0
  id: netmon_metric_microburst_queue_occupancy_pct_peak_auto
  parameters:
    node: h1
    value: '0.0'
    interval: '1.0'
    jitter: '0.0'
    labels_json: '{}'
    details_json: '{}'
  states: {}
- name: 'blocks_throttle_0 id: blocks_throttle parameters: affinity: '''' alias: '''' comment: '''' maxoutbuf: ''0'' minoutbuf: ''0'' samples_per_second: samp_rate vlen: ''1'' states: bus_sink: false bus_source: false bus_structure: null coordinate: [312, 208.0] rotation: 0 state: true'
  id: ''
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: microburst_queue_occupancy_pct_peak
    marker1: '0'
    size: '30'
    srate: samp_rate
    style1: '0'
    type: float
    update_time: '0.1'
    ymin: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    color: '""'
    debug: 'True'
    show: 'True'
    stream: 'False'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_metric_microburst_queue_occupancy_pct_peak_auto_0, tick]
- [netmon_metric_microburst_queue_occupancy_pct_peak_auto_0, out, blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [netmon_metric_microburst_queue_occupancy_pct_peak_auto_0, metrics, blocks_message_debug_0, print]

metadata:
  file_format: 1
