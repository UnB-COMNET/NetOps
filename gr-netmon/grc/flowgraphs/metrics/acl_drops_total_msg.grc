options:
  parameters:
    author: jon
    generate_options: qt_gui
    id: metric_acl_drops_total_msg
    output_language: python
    title: Metric acl_drops_total (msg)
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_NIL
    period: '1000'
  states: {}
- name: netmon_metric_acl_drops_total_msg_0
  id: netmon_metric_acl_drops_total_msg
  parameters:
    details_json: '{}'
    labels_json: '{}'
    node: h1
    value: '0.0'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_metric_acl_drops_total_msg_0, tick]
- [netmon_metric_acl_drops_total_msg_0, metrics, blocks_message_debug_0, print]

metadata:
  file_format: 1
