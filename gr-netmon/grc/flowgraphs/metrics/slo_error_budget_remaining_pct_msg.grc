options:
  parameters:
    author: jon
    generate_options: qt_gui
    id: metric_slo_error_budget_remaining_pct_msg
    output_language: python
    title: Metric slo_error_budget_remaining_pct (msg)
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_NIL
    period: '1000'
  states: {}
- name: netmon_metric_slo_error_budget_remaining_pct_msg_0
  id: netmon_metric_slo_error_budget_remaining_pct_msg
  parameters:
    node: h1
    value: '0.0'
    labels_json: '{}'
    details_json: '{}'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    color: '""'
    debug: 'True'
    show: 'True'
    stream: 'False'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_metric_slo_error_budget_remaining_pct_msg_0, tick]
- [netmon_metric_slo_error_budget_remaining_pct_msg_0, metrics, blocks_message_debug_0, print]

metadata:
  file_format: 1
