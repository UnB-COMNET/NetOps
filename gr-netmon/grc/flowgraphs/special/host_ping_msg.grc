options:
  parameters:
    author: jon
    generate_options: qt_gui
    id: host_ping_msg
    output_language: python
    title: Host Ping (msg)
  states: {}

blocks:
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: {}
    period: '1000'
  states: {}
- name: netmon_host_ping_msg_0
  id: netmon_host_ping_msg
  parameters:
    container_name: h1
    target_ip: 172.20.0.13
    timeout: '2.0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    color: '""'
    debug: 'True'
    show: 'True'
    stream: 'False'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, netmon_host_ping_msg_0, tick]
- [netmon_host_ping_msg_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
